# Keil uVision project I94_Cyberon.uvproj, settings and files
target UsbCallBack (6160000::V6.16::ARMCLANG)
  device: I94124 Nuvoton
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: DNN_NuOne_UAC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Src\platform\Nuvoton\I94100\Include;..\..\Src\libraries\StdDriver\inc;..\..\Src\app\inc;..\..\Src\driver\inc;..\..\DNN_VR;..\..\Play;..\..\Lib\DSP_LIB\Include
  memory RVCT4: ROM 0x0 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\Aircon.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group App
    ../../Src/app/src/: main.c coder_88C22_88L21_Dmic_Dpwm_8315.c c_stdfx.c appAudioLine.c
  group Platform
    ../../Src/platform/Nuvoton/I94100/Source/: system_I94100.c
    ../../Src/platform/Nuvoton/I94100/Source/ARM/: startup_I94100_KEIL.s
  group Libraries
    ../../Src/libraries/StdDriver/src/: clk.c crc.c dmic.c dpwm.c eadc.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c vad.c wdt.c wwdt.c
  group SystemClk
    ../../Src/driver/src/: SysClk.c SysTick.c
  group Driver
    ../../Src/driver/src/: DMA.c AudioClass.c AudioDesc.c peripheral.c HIRC_AutoTrim.c
  group DNNVR
    ../../DNN_VR/: VR.c AirconModels.c AirconCommands.c AirconVR.c AirconFeedback.c AirconAudio.c libDSpotterSDK_16k23d_I94100_arm-cm4_V2.2.25.2_A_b20260330.lib
  group NuOnePlay
    ../../Play/: AudioRom.c PlayNuOne.c SPIFlash.c NuOneEx_Keil.lib
